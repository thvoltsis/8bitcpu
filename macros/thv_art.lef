VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO thv_art
  CLASS BLOCK ;
  FOREIGN thv_art 0 0 ;
  ORIGIN 0 0 ;
  SIZE 58.380 BY 13.860 ;
  SYMMETRY X Y ;
  OBS
    LAYER met3 ;
      RECT 1.260 1.260 57.120 12.600 ;
  END
END thv_art
END LIBRARY
