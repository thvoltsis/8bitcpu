.subckt thv_art
R1 1 1 1
.ends
