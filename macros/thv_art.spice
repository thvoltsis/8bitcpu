.subckt thv_art
.ends
